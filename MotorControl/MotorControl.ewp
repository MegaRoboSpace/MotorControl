# IAR project MotorControl.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103VE ST STM32F103VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: Sources; Sources\App; Sources\CmdParse; Sources\Common; Sources\Hardware; Sources\ParaVerify; Sources\ProtocolStack; Libraries\Device\CMSIS; Libraries\Device\StdPeriph_Driver\STM32F10x_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MotorControl.bin
  ILINK.IlinkOutputFile: MotorControl.out
  ILINK.IlinkIcfFile: MotorControl.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group (top)
    Sources/: main.c
  group App
    Sources/App/: pvtalgorithm.c
  group CmdParse
    Sources/CmdParse/: calibratecmd.c cmdparse.c debugcmd.c interfacecmd.c motioncmd.c motorcmd.c pvtcmd.c sensorcmd.c systemcmd.c updatecmd.c
  group Common
    Sources/Common/: msgescape.c softtimer.c streambuffer.c
  group Device/CMSIS
    Libraries/Device/CMSIS/: system_stm32f10x.c
  group Device/Startup
    Libraries/Device/CMSIS/startup/iar/: startup_stm32f10x_hd.s
  group Device/StdPeriph_Driver
    Libraries/Device/StdPeriph_Driver/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Hardware
    Sources/Hardware/: canphy.c interrupt.c timer.c usartphy.c
  group ParaVerify
    Sources/ParaVerify/: intfcparaverify.c motionparaverify.c motorparaverify.c paraverify.c pvtparaverify.c sensorparaverify.c systemparaverify.c
  group ProtocolStack
    Sources/ProtocolStack/: canmac.c protocolstack.c usartmac.c
